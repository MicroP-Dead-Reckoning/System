# Keil uVision project LCD Base Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD Base Project
  c flags: Optim=1 wLevel=2
  c define: HSE_VALUE=8000000 USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\inc;.\src; .\Wireless\inc; .\Tests
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c fputc_debug.c
    ./Wireless/src/: cc2500.c
    ./Wireless/inc/: cc2500.h
  group Images
    ./inc/: background16bpp.h
  group Gyroscope_Drivers
    ./src/: stm32f429i_discovery_l3gd20.c
  group Tests
    ./Tests/: test_control_read.c all_wireless_tests.h test_read_write.c test_wireless.c
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:CRC 1.3.0, Device:StdPeriph Drivers:CRYP 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DBGMCU 1.3.0, Device:StdPeriph Drivers:DCMI 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:DMA2D 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:FMC 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:HASH 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:LTDC 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SAI 1.3.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
